# Keil uVision project experimental_ble_app_uart_s110_pca10028.uvprojx, settings and files
target nrf51422_xxac_s110 (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.4
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: nrf51422_xxac_s110 +hex
  c flags: Optim=4 OneElfS=1
  c define: NRF51 BLE_STACK_SUPPORT_REQD S110 SOFTDEVICE_PRESENT BOARD_PCA10001 BOARD_PCA10028
  c misc: --c99
  library: MicroLIB
  memory RVCT4: ROM 0x16000 size 0x29000
  memory RVCT9: RAM 0x20002000 size 0x6000
  group Application
    ../../: ble_nus.c main.c uart_protocol.c queue.c
  group Documentation
    ../../: Abstract.txt license.txt
  group ::Board Support
    RTE/Board_Support/nRF51422_xxAC/: bsp.c
  group ::Device
    RTE/Device/nRF51422_xxAC/: arm_startup_nrf51.s system_nrf51.c
  group ::nRF_BLE
    C:/Keil_v5/ARM/PACK/NordicSemiconductor/nRF_BLE/1.0.1/common/: ble_srv_common.c
    RTE/nRF_BLE/nRF51422_xxAC/: ble_advdata.c ble_advdata.h ble_conn_params.c ble_conn_params.h
  group ::nRF_Drivers
    C:/Keil_v5/ARM/PACK/NordicSemiconductor/nRF_Drivers/1.1.0/hal/: nrf_delay.c
    RTE/nRF_Drivers/nRF51422_xxAC/: simple_uart.c simple_uart.h
  group ::nRF_Libraries
    RTE/nRF_Libraries/nRF51422_xxAC/: app_button.c app_button.h app_error.c app_error.h app_gpiote.c app_gpiote.h app_scheduler.c app_scheduler.h app_timer.c app_timer.h nrf_assert.c nrf_assert.h app_fifo.c app_fifo.h
  group ::nRF_SoftDevice
    RTE/nRF_SoftDevice/nRF51422_xxAC/: softdevice_handler.c
software components: CMSIS:CORE , Board Support:bsp 7.0.1, Device:Startup 1.0.1, nRF_BLE:BLE_Modules:ble_advdata 1.0.1, nRF_BLE:BLE_Modules:ble_common 1.0.1, nRF_BLE:BLE_Modules:ble_conn_params 1.0.1, nRF_BLE:BLE_Modules:ble_service_common 1.0.1, nRF_Drivers:nrf_delay 1.1.0, nRF_Drivers:nrf_error 1.1.0, nRF_Drivers:nrf_gpio 1.1.0, nRF_Drivers:simple_uart 1.1.0, nRF_Libraries:app_button 1.0.1, nRF_Libraries:app_error 1.0.1, nRF_Libraries:app_fifo 1.0.1, nRF_Libraries:app_gpiote 1.0.1, nRF_Libraries:app_scheduler 1.0.1, nRF_Libraries:app_timer 1.0.1, nRF_Libraries:app_util 1.0.1, nRF_Libraries:nrf_assert 1.0.1, nRF_SoftDevice:Internal:sd_common 1.0.1, nRF_SoftDevice:Internal:softdevice_present 1.0.1, nRF_SoftDevice:s110 7.1.0-2
